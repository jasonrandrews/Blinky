# Keil uVision project Blinky.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.2.0
  cpu: IRAM(0x00000000,0x00080000) IRAM2(0x01000000,0x00200000) XRAM(0x20000000,0x00020000) XRAM2(0x20020000,0x00020000) XRAM3(0x20040000,0x00020000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: Blinky +hex
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x20020000 size 0x20000
  memory RVCT8: RAM 0x20040000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x80000
  memory RVCT10: RAM 0x1000000 size 0x200000
  scatter file: .\RTE\Device\SSE-300-MPS3\fvp_sse300_mps3_s.sct
  group Source Group 1
    ./API/Source/: led_port.c serial.c
    ./API/Include/: led_port.h serial.h
    ./: Blinky.c Blinky.h main.c
  group Documentation
    ./: Abstract.txt
software components: CMSIS Driver:I2C SBCon 1.0.0, CMSIS Driver:MPC 1.0.0, CMSIS Driver:PPC 1.0.0, CMSIS Driver:SPI 1.0.0, CMSIS Driver:USART 1.0.0, CMSIS:CORE 5.4.0, Device:Definition 1.1.0, Device:Startup 1.1.0, Native Driver:Audio I2S 1.0.0, Native Driver:GPIO 1.0.0, Native Driver:I2C SBCon 1.0.0, Native Driver:IO 1.0.0, Native Driver:MPC 1.0.0, Native Driver:PPC 1.0.0, Native Driver:SPI 1.0.0, Native Driver:SysCounter 1.0.0, Native Driver:SysTimer 1.0.0, Native Driver:Timeout 1.0.0, Native Driver:UART 1.0.0, Native Driver:Watch Dog 1.0.0
